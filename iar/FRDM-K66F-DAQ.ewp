# IAR project FRDM-K66F-DAQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SDK_OS_FREE_RTOS; NDEBUG; FSL_RTOS_FREE_RTOS; CPU_MK66FN2M0VLQ18; USE_FRDM_K66F; MK66F18; _DLIB_FILE_DESCRIPTOR; EVAL_LICENSE_TERMS_ACCEPTED; HAVE_CONFIG_H; HAVE_STDINT_H
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../rtos/freertos_9.0.0/Source/portable/MemMang; ../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ..//rtos/freertos_9.0.0/License; ../devices/MK66F18/iar; ../rtos/freertos_9.0.0/Source; ../rtos/freertos_9.0.0; ../rtos/freertos_9.0.0/Source/portable; ../devices/MK66F18/drivers; ../CMSIS/Include; ../devices/MK66F18; ../rtos/freertos_9.0.0/Source/include; ../devices/MK66F18/utilities; ../rtos/freertos_9.0.0/Source/portable/Keil; ../; ; ../tcp stack/common; ../tcp stack/cyclone_crypto; ../tcp stack/cyclone_tcp; ../cJSON-1.7.7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FRDM-K66F-DAQ.hex
  ILINK.IlinkOutputFile: FRDM-K66F-DAQ.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: SDK_OS_FREE_RTOS; NDEBUG; FSL_RTOS_FREE_RTOS; CPU_MK66FN2M0VLQ18
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../rtos/freertos_9.0.0/Source/portable/MemMang; ../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../rtos/freertos_9.0.0/License; ../devices/MK66F18/iar; ../rtos/freertos_9.0.0/Source; ../rtos/freertos_9.0.0; ../rtos/freertos_9.0.0/Source/portable; ../devices/MK66F18/drivers; ../CMSIS/Include; ../devices/MK66F18; ../rtos/freertos_9.0.0/Source/include; ../devices/MK66F18/utilities; ../rtos/freertos_9.0.0/Source/portable/Keil; ../../..; ../
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MK66FN2M0xxx18_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group cJSON-1.7.7
    ../cJSON-1.7.7/: cJSON.c cJSON.h
  group CMSIS
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h
  group drivers
    ../devices/MK66F18/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_enet.c fsl_enet.h fsl_flexbus.c fsl_flexbus.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lpuart.c fsl_lpuart.h fsl_mpu.c fsl_mpu.h fsl_port.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sdramc.c fsl_sdramc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group freertos
    ../rtos/freertos_9.0.0/: ChangeLogKSDK.txt FreeRTOS_for_Kinetis_SDK_v2.0.txt
    ../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
    ../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_lptmr.c fsl_tickless_systick.c port.c portasm.s portmacro.h
    ../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../rtos/freertos_9.0.0/License/: license.txt
    ../rtos/freertos_9.0.0/Source/portable/: readme.txt
    ../rtos/freertos_9.0.0/Source/portable/Keil/: See-also-the-RVDS-directory.txt
  group sources
    ../tcp stack/common/: debug.c
    ../: frdm_k66f.h FreeRTOSConfig.h main.c os_port_config.h res.c retarget.c variables.c variables.h
  group sources/AccessControl
    ../: access_control.c access_control.h
  group sources/am2320
    ../: am2320.c am2320.h
  group sources/ethernet
    ../: app_ethernet.c app_ethernet.h
  group sources/ExternalDrivers
    ../: eeprom_rtc.c eeprom_rtc.h lm2068.c lm2068.h
  group sources/ftp
    ../: ftp.c ftp.h
  group sources/hal
    ../: hal_system.c hal_system.h
  group sources/i2c
    ../: i2c_lock.c i2c_lock.h
  group sources/initialization
    ../: adc_config.h app_init.c app_init.h
  group sources/menu
    ../: menu.c menu.h
  group sources/modem
    ../: modem.c modem.h modem_interface.c modem_interface.h modem_ports.h uart_driver.c uart_driver.h
  group sources/mqtt_client
    ../mqtt_client/: app_mqtt_client.c app_mqtt_client.h mqtt_json_make.c mqtt_json_make.h mqtt_json_parse.c mqtt_json_parse.h mqtt_json_type.h
  group sources/network
    ../: crypto_config.h net_config.h
  group sources/network/rs485
    ../: rs485.c rs485.h
  group sources/snmpv3
    ../: private_mib_impl.c private_mib_impl.h private_mib_module.c private_mib_module.h snmp_client.c snmp_client.h snmpConnect_manager.c snmpConnect_manager.h
  group sources/task
    ../: user_task.c user_task.h
  group sources/test
    ../: test.c test.h
  group startup
    ../devices/MK66F18/iar/: startup_MK66F18.s
    ../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group tcp stack/common
    ../tcp stack/common/: compiler_port.h date_time.c date_time.h debug.h endian.c endian.h error.h fs_port.h os_port.h os_port_freertos.c os_port_freertos.h path.c path.h resource_manager.c resource_manager.h str.c str.h
    ../: debug.c
  group tcp stack/cyclone_crypto
    ../tcp stack/cyclone_crypto/: aes.c aes.h asn1.c asn1.h cipher_mode_cbc.c cipher_mode_cbc.h cipher_mode_cfb.c cipher_mode_cfb.h crypto.h des.c des.h hmac.c hmac.h md5.c md5.h oid.c oid.h sha1.c sha1.h yarrow.c yarrow.h
  group tcp stack/cyclone_tcp/core
    ../tcp stack/cyclone_tcp/core/: bsd_socket.c bsd_socket.h ethernet.c ethernet.h ip.c ip.h net.c net.h net_legacy.h net_mem.c net_mem.h nic.c nic.h ping.c ping.h raw_socket.c raw_socket.h socket.c socket.h tcp.c tcp.h tcp_fsm.c tcp_fsm.h tcp_misc.c tcp_misc.h tcp_timer.c tcp_timer.h udp.c udp.h
  group tcp stack/cyclone_tcp/dhcp
    ../tcp stack/cyclone_tcp/dhcp/: dhcp_client.c dhcp_client.h dhcp_common.c dhcp_common.h dhcp_debug.c dhcp_debug.h dhcp_server.c dhcp_server.h
  group tcp stack/cyclone_tcp/dns
    ../tcp stack/cyclone_tcp/dns/: dns_cache.c dns_cache.h dns_client.c dns_client.h dns_common.c dns_common.h dns_debug.c dns_debug.h
  group tcp stack/cyclone_tcp/drivers
    ../tcp stack/cyclone_tcp/drivers/: ksz8081.c ksz8081.h mk6x_eth.c mk6x_eth.h
  group tcp stack/cyclone_tcp/ftp
    ../tcp stack/cyclone_tcp/ftp/: ftp_client.c ftp_client.h ftp_server.c ftp_server.h ftp_server_commands.c ftp_server_commands.h ftp_server_events.c ftp_server_events.h ftp_server_misc.c ftp_server_misc.h
  group tcp stack/cyclone_tcp/http
    ../tcp stack/cyclone_tcp/http/: http_server.c http_server.h http_server_auth.c http_server_auth.h http_server_misc.c http_server_misc.h mime.c mime.h ssi.c ssi.h
  group tcp stack/cyclone_tcp/ipv4
    ../tcp stack/cyclone_tcp/ipv4/: arp.c arp.h auto_ip.c auto_ip.h icmp.c icmp.h igmp.c igmp.h ipv4.c ipv4.h ipv4_frag.c ipv4_frag.h
  group tcp stack/cyclone_tcp/ipv6
    ../tcp stack/cyclone_tcp/ipv6/: icmpv6.c icmpv6.h ipv6.c ipv6.h ipv6_frag.c ipv6_frag.h ipv6_misc.c ipv6_misc.h ipv6_pmtu.c ipv6_pmtu.h ipv6_routing.c ipv6_routing.h mld.c mld.h ndp.c ndp.h ndp_cache.c ndp_cache.h ndp_misc.c ndp_misc.h ndp_router_adv.c ndp_router_adv.h slaac.c slaac.h
  group tcp stack/cyclone_tcp/mdns
    ../tcp stack/cyclone_tcp/mdns/: mdns_client.c mdns_client.h mdns_common.c mdns_common.h mdns_responder.c mdns_responder.h
  group tcp stack/cyclone_tcp/mibs
    ../tcp stack/cyclone_tcp/mibs/: mib2_impl.c mib2_impl.h mib2_module.c mib2_module.h mib_common.c mib_common.h
  group tcp stack/cyclone_tcp/mqtt
    ../tcp stack/cyclone_tcp/mqtt/: mqtt_client.c mqtt_client.h mqtt_client_misc.c mqtt_client_misc.h mqtt_client_packet.c mqtt_client_packet.h mqtt_client_transport.c mqtt_client_transport.h mqtt_common.h
  group tcp stack/cyclone_tcp/netbios
    ../tcp stack/cyclone_tcp/netbios/: nbns_client.c nbns_client.h nbns_common.c nbns_common.h nbns_responder.c nbns_responder.h
  group tcp stack/cyclone_tcp/ppp
    ../tcp stack/cyclone_tcp/ppp/: chap.c chap.h ipcp.c ipcp.h ipv6cp.c ipv6cp.h lcp.c lcp.h pap.c pap.h ppp.c ppp.h ppp_debug.c ppp_debug.h ppp_fsm.c ppp_fsm.h ppp_hdlc.c ppp_hdlc.h ppp_misc.c ppp_misc.h
  group tcp stack/cyclone_tcp/snmp
    ../tcp stack/cyclone_tcp/snmp/: snmp_agent.c snmp_agent.h snmp_agent_dispatch.c snmp_agent_dispatch.h snmp_agent_misc.c snmp_agent_misc.h snmp_agent_pdu.c snmp_agent_pdu.h snmp_common.c snmp_common.h snmp_usm.c snmp_usm.h
  group utilities
    ../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_sbrk.c fsl_shell.c fsl_shell.h
